options:
  parameters:
    author: ChunChih Lin
    generate_options: qt_gui
    id: Stream_test
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("Monitor_1s")
    period: '1000'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, blocks_message_debug_0, print]

metadata:
  file_format: 1
