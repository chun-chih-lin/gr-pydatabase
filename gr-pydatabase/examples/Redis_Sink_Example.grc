options:
  parameters:
    author: root
    generate_options: qt_gui
    id: redis_sink_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '100'
    minsize: '20'
  states: {}
- name: pydatabase_redis_sink_0
  id: pydatabase_redis_sink
  parameters:
    db_ch: channel_1
    db_host: localhost
    db_idx: '0'
    db_port: '6379'
  states: {}
- name: pydatabase_redis_source_0
  id: pydatabase_redis_source
  parameters:
    db_ch: channel_1
    db_host: localhost
    db_idx: '0'
    db_port: '6379'
  states: {}

connections:
- [blocks_random_pdu_0, pdus, pydatabase_redis_sink_0, pdu]
- [pydatabase_redis_source_0, pdu, blocks_random_pdu_0, generate]

metadata:
  file_format: 1
