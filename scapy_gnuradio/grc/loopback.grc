options:
  parameters:
    author: root
    generate_options: qt_gui
    id: loopback
    output_language: python
    title: loopback
  states: {}

blocks:
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {state: disabled}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: foo_channel_model_0
  id: foo_channel_model
  parameters:
    block_tags: 'False'
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0794328'
    seed: '0'
    taps: '1.0'
  states: {}
- name: foo_packet_pad2_0
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    pad_front: '500'
    pad_tail: '500'
  states: {}
- name: ieee802_11_mac_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0xff, 0xff, 0xff, 0xff, 0xff, 0xff]'
    dst_mac: '[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]'
    src_mac: '[0x23, 0x23, 0x23, 0x23, 0x23, 0x23]'
  states: {state: disabled}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'True'
    log: 'False'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      To use this grc.
      1. Run the grc.
      2. Use python script which launch a socket object listen to
           port 52001 with ip 127.0.0.1.
      3. Whenever the python script sendto a MESSAGE to the ip
           with the port, it will trigger this grc to transmit the desired
           MESSAGE.

      A template python script is shown as follow:
      --- Python ---
      import socket

      MESSAGE = "Hello, from python!\n"

      sock = socket.socket(socket.AF_INET, socket.SOCK_DGRAM)
      sock.sendto(MESSAGE.encode(), ("127.0.0.1", 52001))
      --- EOF ---
    note: README.md
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: |-
      To run with scapy in python.
      1. install scapy in the system
      	~$ pip install --pre scapy[basic]
      2. import scapy packet in the python.
      --- python ---
      import socket
      import scapy.all as scapy

      frame = scapy.Ether(dst="ff:..")\
      	/scapy.IP(dst=["gnuradio.org", "libvolk.org", ttl=(1,9)])\
      	/scapy.UDP(sport=12345, dport=52001)/"Hello World!"
      list(frame)[0].show()

      sock = socket.socket(socket.AF_INET, socket.SOCK_DGRAM)
      sock.sendto(byte(frame), ("127.0.0.1", 52001))

      --- EOF ---


      Refer:
      https://archive.fosdem.org/2019/schedule/event/gr_scapy/attachments/slides/3366/export/events/attachments/gr_scapy/slides/3366/gnuradio_meets_scapy.pdf
    note: README.md
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '480'
    type: complex
  states: {}
- name: wifi_phy_hier_0
  id: wifi_phy_hier
  parameters:
    bandwidth: 10e6
    chan_est: ieee802_11.LS
    encoding: ieee802_11.BPSK_1_2
    frequency: 5.89e9
    sensitivity: '0.56'
  states: {}

connections:
- [blocks_pdu_to_tagged_stream_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_socket_pdu_0, pdus, ieee802_11_mac_0, app in]
- [blocks_socket_pdu_0_0, pdus, blocks_message_debug_0, print_pdu]
- [blocks_socket_pdu_0_0, pdus, wifi_phy_hier_0, mac_in]
- [foo_channel_model_0, '0', wifi_phy_hier_0, '0']
- [foo_packet_pad2_0, '0', foo_channel_model_0, '0']
- [ieee802_11_mac_0, phy out, blocks_message_debug_0, print_pdu]
- [ieee802_11_mac_0, phy out, wifi_phy_hier_0, mac_in]
- [wifi_phy_hier_0, '0', foo_packet_pad2_0, '0']
- [wifi_phy_hier_0, carrier, blocks_pdu_to_tagged_stream_0, pdus]
- [wifi_phy_hier_0, mac_out, ieee802_11_parse_mac_0, in]

metadata:
  file_format: 1
